## config/boards/shields/protractor/Kconfig.defconfig
```kconfig
if SHIELD_PROTRACTOR

config ZMK_KEYBOARD_NAME
	default "protractor"

config ZMK_SLEEP
	default n

endif
```
